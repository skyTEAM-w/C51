# Keil uVision project Scan.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Scan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Key.c Key.h SEG.c SEG.h Timer0Init.c Timer0Init.h AT24C02.c AT24C02.h I2C.c I2C.h
