# Keil uVision project SERIAL1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SERIAL1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main1.c BasicalFunc.c BasicalFunc.h
